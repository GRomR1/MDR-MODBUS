# Keil uVision project MDR-MODBUS.uvproj, settings and files
target MDR-MODBUS (ARM-ADS)
  device: MDR32F9Q2I Milandr
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MDR-MODBUS
  c flags: Optim=1
  c include: ..\MDR-freemodbus;.\modbus;.\modbus\ascii;.\modbus\functions;.\modbus\include;.\modbus\rtu;.\modbus\tcp;.\port;.\SPL\inc;.\SPL\src;.\Config;.\System
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group System
    ./System/: MDR32Fx.h startup_MDR32F9Qx.s system_MDR32F9Qx.c system_MDR32F9Qx.h
  group Modbus
    ./modbus/: mb.c
    ./modbus/ascii/: mbascii.c
    ./modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./modbus/rtu/: mbcrc.c mbrtu.c
    ./modbus/tcp/: mbtcp.c
  group PortModbus
    ./port/: port.h portevent.c portserial.c porttimer.c
  group Main
    ./: demo.c
  group SPL
    ./SPL/src/: MDR32F9Qx_uart.c MDR32F9Qx_timer.c MDR32F9Qx_ssp.c MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c
  group Config
    ./Config/: MDR32F9Qx_board.h MDR32F9Qx_config.h
